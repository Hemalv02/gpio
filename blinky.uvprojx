# Keil uVision project blinky.uvprojx, settings and files
target Target_1 (6230000::V6.23::ARMCLANG)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: blinky
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group src
    ./: main.c
  group include
    ./: CLOCK.h GPIO.h SYS_INIT.h
  group lib
    ./: CLOCK.c GPIO.c SYS_INIT.c
software components: CMSIS-Compiler:CORE 1.1.0, CMSIS:CORE 6.1.0, Device:Startup 2.6.3
